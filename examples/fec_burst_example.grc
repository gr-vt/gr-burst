<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>100</value></param>
</block>
<block>
<key>variable_cc_def_fecapi_tpc_encoder_def</key>
<param><key>id</key><value>tpce1</value></param>
<param><key>value</key><value>"ok"</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>dim1</key><value>1</value></param>
<param><key>dim2</key><value>4</value></param>
<param><key>row_poly</key><value>[3]</value></param>
<param><key>col_poly</key><value>[43]</value></param>
<param><key>krow</key><value>26</value></param>
<param><key>kcol</key><value>6</value></param>
<param><key>bval</key><value>9</value></param>
<param><key>qval</key><value>3</value></param>
</block>
<block>
<key>variable_cc_def_fecapi_tpc_decoder_def</key>
<param><key>id</key><value>tpcd1</value></param>
<param><key>value</key><value>"ok"</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>dim1</key><value>1</value></param>
<param><key>dim2</key><value>4</value></param>
<param><key>row_poly</key><value>[3]</value></param>
<param><key>col_poly</key><value>[43]</value></param>
<param><key>krow</key><value>26</value></param>
<param><key>kcol</key><value>6</value></param>
<param><key>bval</key><value>9</value></param>
<param><key>qval</key><value>3</value></param>
<param><key>max_iter</key><value>6</value></param>
<param><key>decoder_type</key><value>0</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>minsize</key><value>144</value></param>
<param><key>maxsize</key><value>144</value></param>
</block>
<block>
<key>generic_encoder_async</key>
<param><key>id</key><value>generic_encoder_async_0</value></param>
<param><key>encoder</key><value>tpce1[0]</value></param>
</block>
<block>
<key>generic_decoder_async</key>
<param><key>id</key><value>generic_decoder_async_0</value></param>
<param><key>decoder</key><value>tpcd1[0]</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>144</value></param>
<param><key>srate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>generic_encoder_async_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>generic_encoder_async_0</source_block_id><sink_block_id>generic_decoder_async_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>generic_decoder_async_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
